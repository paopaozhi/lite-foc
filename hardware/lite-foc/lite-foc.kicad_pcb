# Repository paopaozhi/lite-foc

File README.md:

# 基于CMake工程示例工程

本项目自带一个包管理器，可以方便的管理开发嵌入式软件所需的包，使用现代化构建工具构建项目，对常用的IDE作了应有的配置，可以更方便的进行开发。

> [!tip]
> 本项目不是新手项目，需要一定的嵌入式编程基础和对嵌入式工具链的了解

## 快速开始

### 命令行

```shell
python uility.py
cmake --build build/Debug
ninjia -j 4
```

### vscode

必备插件：

- CMake Tools
- C/C++

vscode 打开工程后，下载好对于插件，配置CMake预设为`Debug`，点击小齿轮编译

`Ctrl+Shift+B`运行`flash firmware`任务下载到开发板

## 示例开发板

来自微行工作室的STM32F411开发板[项目链接](https://gitee.com/WeAct-TC/WeActStudio.MiniSTM32F4x1)

## KiCad design hardware/lite-foc/lite-foc.kicad_pcb

Parts:
C1, C2: 8pF; C_0805_2012Metric
C3, C4, C5, C6, C7, C9, C10, C12, C14, C15, C19, C21, C28: 0.1uF; C_0805_2012Metric
C8, C11, C18, C23, C24, C25: 10uF; C_0805_2012Metric
C13: 100K; C_0805_2012Metric
C16, C17, C20, C22: 100uF; C_0805_2012Metric
C26: 100uf; C_0805_2012Metric
C27: 10nF; C_0805_2012Metric
C29: 0.47uF; C_0805_2012Metric
D1: SS54; D_SMA
D2: LED; LED_0805_2012Metric
D3: SMBJ5.0CA; D_SMA
D4, D5, D6: B5817WS; D_SOD-323
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: Conn_01x02_MountingPin; JST_SHL_SM02B-SHLS-TF_1x02-1MP_P1.00mm_Horizontal
J3: Conn_01x03; AMASS_MR30PW-M_1x03_P3.50mm_Horizontal
J4: Conn_01x03_MountingPin; JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical
J5: Conn_01x02; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
L1: 6.8uH; L_0805_2012Metric
R1, R2: 0.01; R_0805_2012Metric
R3: 120; R_0805_2012Metric
R4, R6, R11, R14: 10K; R_0805_2012Metric
R5: 3.3K; R_0805_2012Metric
R7, R8: 22; R_0805_2012Metric
R9: 1.8K; R_0805_2012Metric
R10: 1.5K; R_0805_2012Metric
R12: 2K; R_0805_2012Metric
R13: 1M; R_0805_2012Metric
R15, R16: 5.1K; R_0805_2012Metric
SW1: CK_KMS2xxG; SW_SPST_CK_KMS2xxG
U1, U2: INA240A2PW; TSSOP-8_4.4x3mm_P0.65mm
U3: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U4: STM32F411CEUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm
U5: LP2992 3V3; SOT-23-5
U6: ME3116; SOT-23-6
U7: DRV8313PWP; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP3.4x9.5mm_Mask2.4x6.17mm
Y1: 8M; Crystal_SMD_0603-2Pin_6.0x3.5mm

Connections:
+3.3V: C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, C10.1, C11.1, C19.1, C23.1, R4.1, R6.1, U1.5 (V+), U1.6 (REF2), U2.5 (V+), U2.6 (REF2), U3.3 (VCC), U4.1 (VBAT), U4.9 (VDDA), U4.24 (VDD), U4.36 (VDD), U4.48 (VDD), U5.5 (VOUT)
+5V: C13.1, C21.2, C25.2, D2.2 (A), D4.1 (K), J4.3, L1.2, R11.1, U5.1 (VIN), U5.3 (ON/OFF)
/CAN_D: U3.1 (D), U4.45 (PB8)
/CAN_H: J2.1, R3.1, U3.7 (CANH)
/CAN_L: J2.2, R3.2, U3.6 (CANL)
/CAN_R: U3.4 (R), U4.46 (PB9)
/DRV_EN: U4.25 (PB12), U7.22 (EN3), U7.24 (EN2), U7.26 (EN1)
/DRV_FAULT: R14.2, U7.18 (NFAULT)
/Encoder_PWM: J4.1, U4.30 (PA9)
/MOTOR_A: J3.1, R1.2, U1.2 (+)
/MOTOR_A_CS: R1.1, U1.3 (-), U7.5 (OUT1)
/MOTOR_B: J3.2, R2.2, U2.3 (-)
/MOTOR_B_CS: R2.1, U2.2 (+), U7.8 (OUT2)
/MOTOR_C: J3.3, U7.9 (OUT3)
/NRST: C12.1, R6.2, SW1.1, U4.7 (NRST)
/OSC_IN: C2.2, U4.5 (PH0), Y1.2
/OSC_OUT: C1.2, U4.6 (PH1), Y1.1
/PWM_A: U4.40 (PB4), U7.27 (IN1)
/PWM_B: U4.41 (PB5), U7.25 (IN2)
/PWM_C: U4.18 (PB0), U7.23 (IN3)
/SENSE_A: U1.8, U4.10 (PA0)
/SENSE_B: U2.8, U4.11 (PA1)
/USB_DM: R7.2, U4.32 (PA11)
/USB_DM_IN: J1.A7 (D-), J1.B7 (D-), R7.1
/USB_DP: R8.2, R10.1, U4.33 (PA12)
/USB_DP_IN: J1.A6 (D+), J1.B6 (D+), R8.1
/V3P3: R14.1, U7.16 (NRESET), U7.17 (NSLEEP)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C12.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.2, C24.1, C25.1, C26.2, C29.2, D3.1 (K), D5.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.MP (MountPin), J4.2, J4.MP (MountPin), J5.2, R9.2, R12.2, R15.2, R16.2, SW1.2, SW1.SH (B), U1.1 (GND), U1.4 (GND), U1.7 (REF1), U2.1 (GND), U2.4 (GND), U2.7 (REF1), U3.2 (GND), U4.23 (VSS), U4.35 (VSS), U4.44 (BOOT0), U4.47 (VSS), U4.49 (VSS), U5.2 (GND), U6.2 (GND), U7.6 (PGND1), U7.7 (PGND2), U7.10 (PGND3), U7.12 (COMPP), U7.13 (COMPN), U7.14 (GND), U7.20 (GND), U7.28 (GND), U7.29 (TH_PAD)
GNDA: C8.2, C10.2, C11.2, R5.2, U4.8 (VSSA)
unnamed: C8.1, R4.2, R5.1
unnamed: C14.2, C15.2, L1.1
unnamed: D2.1 (K), R12.1
unnamed: D5.1 (K), U6.6 (SW)
unnamed: C24.2, D6.1 (K), R13.2, U6.5 (IN)
unnamed: J1.A5 (CC1), R16.1
unnamed: J1.B5 (CC2), R15.1
unnamed: C18.1, U5.4 (BYPASS)
unnamed: C14.1, C15.1, U6.1 (BS)
unnamed: R13.1, U6.4 (EN)
unnamed: C13.2, R9.1, R11.2, U6.3 (FB)
unnamed: C27.2, U7.2 (CPH)
unnamed: C27.1, U7.1 (CPL)
unnamed: C29.1, U7.15 (V3P3)
unnamed: C28.1, U7.3 (VCP)
VBUS: D4.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R10.2
VCC: C16.1, C17.1, C20.1, C22.1, C26.1, C28.2, D1.1 (K), D3.2 (A), D6.2 (A), U7.4 (VM1), U7.11 (VM2)
VCC_IN: D1.2 (A), J5.1

Notes on the sheet:
三路驱动电路
PWM
COM
CAN
MCU
POWER
SENSE

Board: 4 copper layers, 66 parts (2 on the bottom side), 47 nets, no tracks yet.

## Commit log

2024-05-26 feat:原理图完成接口，最小系统，pwm驱动，电流采样
2024-06-09 feat:原理图绘制完成 初步开始layout
